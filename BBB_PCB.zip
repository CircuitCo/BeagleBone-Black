# Allegro board BeagleBone_Black_RevB4_NOLOGO.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_D11: length 20.2
  TOP w0.121: v1(51.32,30.01) U5.K3 ; v1(60.7,29.57) U12.C2
  BOTTOM w0.121: v1(51.32,30.01) 51.56,30.01 51.69,29.88 51.69,29.59 51.56,29.46 50.55,29.46 50.42,29.34 50.42,29.08 50.55,28.96 57.53,28.96 57.66,28.83 57.66,28.07 57.78,27.94 60.07,27.94 60.2,28.07 60.2,28.32 60.07,28.45 58.17,28.45 58.04,28.57 58.04,28.83 58.17,28.96 60.57,28.96 60.7,29.08 v1(60.7,29.57)
DDR_D12: length 20.2
  TOP w0.121: v1(65.5,31.17) U12.A7 ; U5.K4 v1(50.52,30.01)
  BOTTOM w0.121: v1(65.5,31.17) 65.5,31.53 63.31,33.72 54.55,33.72 52.58,31.75 52.58,30.16 52.45,30.04 52.2,30.04 52.07,30.16 52.07,30.28 51.94,30.41 50.92,30.41 v1(50.52,30.01)
DDR_D13: length 20.2
  TOP w0.121: v1(60.7,31.17) U12.A2 ; v1(51.32,30.81) U5.L3
  LYR3 w0.133: v1(51.32,30.81) 51.64,30.81 52.07,31.24 54.23,31.24 54.36,31.11 54.36,30.1 54.48,29.97 55.5,29.97 55.63,30.1 55.63,31.75 55.5,31.88 53.21,31.88 53.09,32 53.09,32.41 53.21,32.54 60.17,32.54 60.71,32 60.71,31.17 v1(60.7,31.17)
DDR_D14: length 20.3
  TOP w0.121: U5.L4 v1(50.52,30.81) ; v1(66.3,30.37) U12.B8
  BOTTOM w0.121: v1(50.52,30.81) 50.92,31.21 51.53,31.21 54.36,34.04 63.5,34.04 65.9,31.64 65.9,30.77 v1(66.3,30.37)
DDR_D15: length 20.1
  TOP w0.121: U12.A3 60.03,32.64 58.04,32.64 57.91,32.51 57.91,32.26 58.04,32.13 59.31,32.13 59.44,32 59.44,31.75 59.31,31.62 58.04,31.62 57.91,31.5 57.91,31.24 58.04,31.11 59.31,31.11 59.44,30.99 59.44,30.73 59.31,30.61 55.75,30.61 55.63,30.48 55.63,30.23 55.5,30.1 54.48,30.1 54.36,30.23 54.36,30.61 54.48,30.73 54.86,30.73 54.99,30.86 54.99,31.08 54.86,31.21 53.34,31.21 U5.M1
DDR_DQM0: length 23.3
  TOP w0.121: v1(56.13,31.17) 55.7,31.17 55.26,31.61 52.12,31.61 U5.M2 ; v1(65.5,27.97) U12.E7
  BOTTOM w0.121: v1(56.13,31.17) 55.75,31.17 55.63,31.04 55.63,29.59 55.75,29.46 56.52,29.46 56.64,29.59 56.64,31.62 56.77,31.75 60.71,31.75 61.98,30.48 61.98,28.96 62.74,28.19 62.74,27.3 62.87,27.18 64.9,27.18 65.02,27.3 65.02,27.84 65.15,27.97 v1(65.5,27.97)
DDR_DQM1: length 20.2
  TOP w0.121: U5.J2 52.12,29.21 56.52,29.21 56.64,29.34 56.64,30.1 56.77,30.23 59.31,30.23 59.44,30.1 59.44,29.84 59.31,29.72 57.78,29.72 57.66,29.59 57.66,29.34 57.78,29.21 59.31,29.21 59.44,29.08 59.44,28.83 59.31,28.7 57.78,28.7 57.66,28.57 57.66,28.32 57.78,28.19 59.44,28.19 60.01,28.76 61.5,28.76 U12.D3
DDR_DQS0: length 23.3
  TOP w0.095: U12.F3 61.62,26.77 61.54,26.69 61.54,26.44 61.62,26.37 62.22,26.37 62.29,26.44 62.29,26.73 62.37,26.8 62.6,26.8 62.67,26.73 62.67,26.32 62.75,26.24 62.93,26.24 63.22,26.53 63.22,30.75 61.69,32.28 61.69,32.99 62.01,33.31 62.99,33.31 63.12,33.43 63.12,33.66 62.99,33.78 54.62,33.78 53.76,32.91 52.62,32.91 U5.P1
DDR_DQS1: length 20.3
  TOP w0.095: v1(53.85,30.81) 53.45,30.41 U5.L1
  TOP w0.121: v1(65.5,29.57) U12.C7
  BOTTOM w0.095: v1(65.5,29.57) 65.54,29.57 65.61,29.64 65.61,29.9 65.54,29.97 63.64,29.97 63.35,30.26 63.35,30.85 63.64,31.14 63.91,31.14 64.14,31.37 64.14,31.75 62.86,33.03 54.76,33.03 54.38,32.65 54.38,32.42 54.76,32.04 54.76,31.66 54.47,31.37 53.75,31.37 53.62,31.24 53.62,31.04 v1(53.85,30.81)
DDR_DQSN0: length 23.3
  TOP w0.095: U5.P2 52.1,33.19 53.64,33.19 54.51,34.06 63.11,34.06 63.4,33.77 63.4,33.32 63.11,33.03 62.12,33.03 61.97,32.87 61.97,32.39 63.5,30.86 63.5,26.42 63.05,25.97 U12.G3
DDR_DQSN1: length 20.3
  TOP w0.095: v1(53.09,30.81) 52.12,30.81 U5.L2
  TOP w0.121: v1(65.5,30.37) U12.B7
  BOTTOM w0.095: v1(65.5,30.37) 65.39,30.25 63.75,30.25 63.63,30.38 63.63,30.73 63.75,30.86 64.02,30.86 64.41,31.25 64.41,31.87 62.97,33.31 54.64,33.31 54.1,32.77 54.1,32.31 54.48,31.93 54.48,31.78 54.36,31.65 53.63,31.65 53.34,31.36 53.34,31.06 v1(53.09,30.81)
DDR_ODT: length 24.1
  TOP w0.121: v1(59.9,23.16) U12.K1 ; v1(57.91,23.88) 58.04,23.75 58.04,22.1 57.91,21.97 57.68,21.97 57.55,22.1 57.55,23.48 57.4,23.62 57.4,24.26 57.3,24.37 56.86,24.37 56.75,24.26 56.75,21.7 56.64,21.59 56.49,21.59 56.39,21.7 56.39,24.89 56.13,25.15 55.5,25.15 55.12,25.53 55.12,26.42 54.32,27.21 53.68,27.21 U5.G1
  LYR3 w0.133: v1(57.91,23.88) 57.91,24.38 57.66,24.64 57.66,25.02 57.78,25.15 58.17,25.15 58.42,24.89 58.42,23.5 58.29,23.37 58.04,23.37 57.91,23.24 57.91,22.99 58.04,22.86 58.93,22.86 59.23,23.16 v1(59.9,23.16)
DDR_RASN: length 24
  TOP w0.121: U5.G4 v1(50.52,26.81) ; v1(61.5,23.96) U12.J3
  LYR3 w0.121: 51.33,24.77 51.17,24.77 50.92,25.02 50.92,25.41 50.72,25.61 50.34,25.61 50.12,25.83 50.12,26.41 v1(50.52,26.81)
  LYR3 w0.133: 51.33,24.77 54.23,24.77 54.74,25.27 54.74,25.91 54.24,26.4 53.47,26.4 53.34,26.53 53.34,27.43 53.47,27.56 54.99,27.56 56.5,26.05 57.77,26.05 59.42,24.4 61.35,24.4 61.59,24.64 62.1,24.64 62.84,23.9 62.84,23.72 62.69,23.58 62.51,23.58 62.12,23.96 v1(61.5,23.96)
DDR_RESETN: length 20.7
  TOP w0.121: U12.T2 v1(60.7,18.36) 60.24,17.91 58.8,17.91 58.67,18.03 58.67,21.72 58.42,21.97 58.42,24.64 57.89,25.16 56.75,25.16 56.39,25.53 55.75,25.53 55.5,25.78 55.5,26.54 54.43,27.61 52.12,27.61 U5.G2
  BOTTOM w0.121: R97.2 62.36,19.16 61.96,18.76 U12.T2 v1(60.7,18.36)
DDR_VREF: length 26.3
  TOP w0.121: v1(50.52,28.41) U5.J4 ; v1(66.3,21.56) U12.M8 ; v1(59.9,25.57) U12.H1
  BOTTOM w0.121: v1(66.3,21.56) 65.17,21.56 64.77,21.96 C124.1 R100.1 64.01,23.62 63.82,23.81 63.18,23.81 62.99,24 C123.1 R98.2 ; v1(50.52,28.41) 50.92,28.01 54.03,28.01 54.88,27.17 C28.1 55.37,26.8 55.5,26.67 62.61,26.67 62.99,26.29 R98.2 ; v1(59.9,25.57) 60.32,25.15 61.98,25.15 62.4,25.57 R98.2
DDR_VTP: length 4.6
  TOP w0.254: v1(51.32,28.41) U5.J3
  BOTTOM w0.381: v1(51.32,28.41) R22.2
DDR_WEN: length 23.9
  TOP w0.121: v1(55.37,17.53) 53.47,19.43 53.47,20.32 52.96,20.83 52.24,20.83 52.12,20.95 52.12,22.57 51.72,22.97 U5.B2 ; v1(61.5,22.36) U12.L3
  LYR3 w0.133: v1(55.37,17.53) 55.38,17.52 55.63,17.52 56.77,16.38 62.23,16.38 63.12,17.27 63.12,20.57 63.5,20.95 63.5,21.72 62.48,22.73 61.87,22.73 v1(61.5,22.36)
DVI_+5V: length 22.2
  BOTTOM w0.203: 79.21,27.05 79.31,26.95 P6.19
  BOTTOM w0.381: 79.21,27.05 78.64,27.62 76.33,27.62 ; 76.33,27.62 R147.1 ; 76.33,27.62 R146.1 74.61,26.99
  BOTTOM w0.508: 74.61,26.99 71.75,24.13 71.75,14.61 RT1.2
EHRPWM1A: length 41.9
  TOP w0.121: v1(40.01,38.1) 40.26,38.1 41.72,36.64 41.72,35.61 U5.U14
  LYR4 w0.133: v1(40.01,38.1) 39.75,37.85 38.73,37.85 37.34,36.45 37.34,35.81 37.12,35.6 36.23,35.6 34.8,34.16 34.8,23.27 34.54,23.02 34.54,17.27 33.55,16.28 33.55,5.82 P9.14
EHRPWM1B: length 37.1
  TOP w0.121: v1(41.72,34.81) U5.T14
  LYR4 w0.133: v1(41.72,34.81) 41.22,35.31 39.75,35.31 38,33.55 36.6,33.55 36.32,33.27 36.32,24.51 36.49,24.35 36.49,19.34 35.56,18.41 35.56,10.79 37.47,8.89 P9.16
EHRPWM2A: length 16.8
  TOP w0.121: U5.U10 45.72,35.61 45.72,36.39 46.18,36.85 46.18,38.53 44.58,40.13 44.58,48.13 P8.19
EHRPWM2B: length 27.5
  TOP w0.121: v1(44.92,34.81) U5.T10
  LYR3 w0.133: P8.13 32,47.24 32,44.32 32.26,44.07 32.26,42.42 32.64,42.04 41.27,42.04 42.8,40.51 42.8,39.37 43.43,38.73 43.43,36.58 44.92,35.09 v1(44.92,34.81)
EMMC_RSTN: length 4.8
  TOP w0.203: U13.K5 v2(29.09,43.66)
  BOTTOM w0.121: v2(29.09,43.66) 29.09,44.45 29.21,44.57 R111.2 R162.2
EMMC_VCCI: length 1.9
  TOP w0.121: U13.C2 v2(32.35,44.91)
  BOTTOM w0.121: C125.1 32.38,44.95 v2(32.35,44.91)
ENZ_KALDO_1P8V: length 3.4
  TOP w0.121: U5.B4 v1(50.52,22.81)
  BOTTOM w0.121: v1(50.52,22.81) 51.12,22.21 R54.2
ETH_TXD4: length 4.4
  TOP w0.121: v1(29.21,34.61) 26.73,34.61 26.33,34.21 U14.18
  BOTTOM w0.121: R145.1 v1(29.21,34.61)
GPIO0_7: length 48
  TOP w0.121: v1(36.07,18.03) 36.32,18.29 R50.1
  BOTTOM w0.121: v1(36.07,18.03) 36.07,19.05 36.47,19.45 36.47,19.96 36.7,20.19 39.12,20.19 40.13,19.18 R51.1 40.64,18.54 41.27,17.91 41.27,14.22 42.09,13.4 46.81,13.4 46.99,13.59 60.45,13.59 61.47,12.57 61.47,9.65 65.09,6.03 68.9,6.03 P9.42
GPIO0_7SRC: length 9.6
  TOP w0.121: U5.C18 38.62,24.01 37.08,22.48 37.08,20.95 36.57,20.44 36.06,20.44 35.56,19.94 35.56,17.78 36.07,17.27 R50.2
GPIO0_26: length 30.4
  TOP w0.121: v1(44.12,34.81) U5.T11
  LYR3 w0.133: v1(44.12,34.81) 44.12,35.38 43.05,36.45 43.05,38.48 42.42,39.12 42.42,40.39 41.02,41.78 32.38,41.78 32,42.16 32,43.81 31.62,44.2 31.62,48.39 32.13,48.9 32.64,48.9 33.66,49.91 33.66,51.44 P8.14
GPIO0_27: length 16.6
  TOP w0.121: P8.17 43.05,47.12 43.05,45.09 43.43,44.7 43.43,36.32 43.32,36.21 43.32,35.61 U5.U12
GPIO1_12: length 29.8
  TOP w0.121: v1(43.32,34.81) U5.T12
  LYR3 w0.133: P8.12 30.99,51.31 30.99,41.66 31.5,41.15 40.64,41.15 41.66,40.13 41.66,38.8 41.94,38.52 41.94,38.06 41.7,37.82 41.66,37.82 41.66,36.83 43.32,35.17 v1(43.32,34.81)
GPIO1_13: length 27.9
  TOP w0.121: v1(43.32,34.01) U5.R12
  LYR3 w0.121: v1(43.32,34.01) 43.72,34.41 43.72,35.27
  LYR3 w0.133: 43.72,35.27 42.07,36.92 42.07,37.86 42.17,37.96 42.17,38.62 42.07,38.72 42.07,40.23 40.77,41.53 31.62,41.53 31.27,41.89 31.27,49.05 P8.11
GPIO1_14: length 20
  TOP w0.121: P8.16 38.73,51.44 38.73,49.53 39.76,48.51 41.15,48.51 42.04,47.62 42.04,45.59 43.18,44.45 43.18,36.58 42.92,36.32 U5.V13
GPIO1_15: length 18.4
  TOP w0.121: U5.U13 42.52,35.61 42.52,36.43 42.92,36.83 42.92,44.2 41.78,45.34 41.78,47.37 41.02,48.13 39.5,48.13 P8.15
GPIO1_16: length 51.3
  LYR4 w0.133: v1(37.15,43.18) 36.2,42.23 36.2,39.75 33.53,37.08 33.53,24.26 31.88,22.61 31.62,22.61 31.24,22.23 31.24,19.68 31.75,19.18 31.75,7.37 31.24,6.86 31.24,4.06 32.26,3.05 36.32,3.05 P9.15
  BOTTOM w0.121: R160.2 R161.2 v1(37.15,43.18)
GPIO1_17: length 53.5
  TOP w0.121: v1(40.89,38.1) 42.12,36.87 U5.V14
  LYR4 w0.133: v1(35.31,6.48) 34.92,6.86 34.92,7.29 34.8,7.41 34.8,22.94 35.05,23.19 35.05,34.04 36.38,35.36 37.27,35.36 37.59,35.69 37.59,36.2 38.99,37.59 40.39,37.59 v1(40.89,38.1)
  BOTTOM w0.121: v1(35.31,6.48) 36.2,5.59 45.59,5.59 46.35,4.83 46.35,3.17 P9.23
GPIO1_28: length 37.4
  TOP w0.121: v1(36.83,36) 37.62,35.21 U5.U18
  LYR4 w0.133: P9.12 32.38,5.59 32.66,5.87 32.66,16.41 34.04,17.78 34.04,23.24 34.29,23.5 34.29,35.56 35.14,36.41 36.42,36.41 v1(36.83,36)
GPIO1_29: length 17.6
  TOP w0.121: U5.V6 48.52,38.36 48.77,38.61 48.77,44.45 49.4,45.09 49.4,49.15 49.15,49.4 49.15,51.69 P8.26
GPIO2_1: length 18.7
  TOP w0.121: U5.V12 43.72,44.96 43.31,45.37 43.31,48.39 42.67,49.02 41.91,49.02 41.27,49.66 41.27,51.44 P8.18
GPIO3_18: length 5.9
  TOP w0.121: U5.B12 43.32,22.81 43.32,22.23 42.6,21.52 42.09,21.52 40.77,20.19 v1(40.01,20.19)
  BOTTOM w0.121: v1(40.01,20.19) R51.2
GPIO3_19: length 28.5
  TOP w0.121: v1(42.52,23.61) U5.C13
  LYR4 w0.133: P9.27 51.56,3.05 49.53,3.05 48.77,3.81 48.77,8 42.93,13.84 42.93,14.61 43.31,14.99 43.31,20.07 41.85,21.52 41.85,22.94 v1(42.52,23.61)
GPIO3_20: length 5.9
  TOP w0.121: U5.D13 v1(42.52,25.21)
  BOTTOM w0.121: v1(42.52,25.21) 42.12,24.81 42.12,21.38 42.55,20.95 R20.2
GPIO3_21: length 66.1
  TOP w0.121: P9.25 48.9,3.17 48.9,4.95 48.01,5.84 44.7,5.84 44.2,6.35 41.78,6.35 39.37,8.76 39.37,11.14 39.66,11.43 40.13,11.43 40.39,11.68 40.39,15.24 38.99,16.64 v1(38.99,19.68) 38.99,20.07 39.75,20.83 40.89,20.83 41.97,21.9 41.97,22.26 U5.A14
  LYR3 w0.133: v1(31.76,21.91) 33.59,21.91 35.1,20.4 38.28,20.4 v1(38.99,19.68)
  LYR4 w0.133: v1(31.76,21.91) 33.78,23.93 33.78,36.83 37.08,40.13 38.86,40.13 39.12,40.39 40.64,40.39 v1(41.15,39.88)
  BOTTOM w0.121: v1(41.15,39.88) 40.96,40.07 R167.2
GRN_C: length 2
  BOTTOM w0.121: P5.10 4.88,32.59 5.21,32.26 R132.2
GRNA: length 32.3
  TOP w0.121: U14.3 24.33,27.8 v1(24.45,27.69)
  LYR3 w0.133: P5.9 3.35,30.68 7.11,26.92 12.19,26.92 14.73,24.38 17.65,24.38 20.95,27.69 21.59,27.69 22.48,28.57 23.56,28.57 v1(24.45,27.69)
HDMI_1V8: length 22.4
  TOP w0.254: v1(65.75,34.83) U11.29 ; U11.46 v1(68.58,42.76) ; v1(68.58,40.13) 68.46,40.25 U11.41 ; v1(58.42,41.78) 58.45,41.76 U11.5 ; v1(58.42,37.34) 58.5,37.25 U11.14 ; U11.36 68.42,37.76 v1(68.58,37.59) 68.58,37.47 68.37,37.25 U11.35 ; v1(64.64,45.21) 64.64,45.19 64.25,44.79 U11.55 ; U11.47 68.58,43.25 ; U11.48 68.52,43.76 v1(68.58,43.81)
  TOP w0.381: v1(68.58,42.76) v1(68.58,43.81)
  BOTTOM w0.381: 68.58,43.31 67.94,43.31 ; 68.58,43.31 v1(68.58,42.76) ; 68.58,43.31 v1(68.58,43.81) ; 64.64,44.32 v1(64.64,45.21) ; 64.64,44.32 C146.1 ; 64.64,44.32 C148.1 ; C150.1 v1(68.58,40.13) ; C145.1 59.05,36.96 58.67,37.34 v1(58.42,37.34) ; C151.1 66.67,37.21 67.06,37.59 v1(68.58,37.59) ; v1(54.48,37.47) 55.57,37.47 FB5.1 55.56,38.1 v1(54.48,38.1) ; v1(58.42,41.78) 58.42,41.4 58.67,41.15 C144.1 ; v1(65.75,34.83) 65.41,35.18 C147.1
HDMI_CEC: length 21.5
  TOP w0.121: v1(75.18,25.91) 74.93,26.16 74.93,29.97 73.93,30.97 D8.1 72.37,30.97 72.14,30.73 69.34,30.73 66.25,33.83 U11.30
  BOTTOM w0.121: v1(75.18,25.91) 75.68,26.4 79.07,26.4 79.32,26.15 P6.15
HDMI_CEC_D: length 1.5
  TOP w0.121: R166.1 D8.2
HDMI_DSCL: length 19.7
  TOP w0.121: v1(78.23,26.99) 77.15,26.99 76.45,27.69 76.45,30.99 74.93,32.51 71.63,32.51 70.48,33.66 69.09,33.66 67.85,34.89 U11.33
  BOTTOM w0.121: 77.34,26.99 v1(78.23,26.99) 78.55,26.67 79.15,26.67 79.27,26.55 P6.17
HDMI_DSDA: length 19.5
  TOP w0.121: U11.32 67.25,34.98 68.96,33.27 70.1,33.27 71.25,32.13 74.8,32.13 75.95,30.99 v1(75.95,29.21)
  BOTTOM w0.121: v1(75.95,29.21) 77.09,29.21 77.34,28.96 77.34,28.26 79.38,28.26 80.59,27.05 81.01,27.05 81.11,26.95 P6.18
HDMI_HPD: length 23
  TOP w0.121: U11.31 66.75,34.98 69.98,31.75 74.42,31.75 75.44,30.73 75.44,27.69 76.58,26.54 79.18,26.54 79.69,26.04 79.69,24.04 v1(78.99,23.35)
  BOTTOM w0.121: P6.1 v1(78.99,23.35)
HDMI_INT: length 40.8
  TOP w0.121: U5.U16 40.12,35.61 39.56,35.61 39.32,35.85 39.32,36.24 38.99,36.58 38.58,36.58 v1(37.57,37.58) ; v1(66.8,45.21) 66.75,45.16 U11.50
  LYR4 w0.133: v1(66.8,45.21) 64.77,47.24 48.39,47.24 46.99,45.85 46.99,44.45 42.01,39.47 39.46,39.47 v1(37.57,37.58)
  BOTTOM w0.121: R158.2 37.57,38.4 v1(37.57,37.58)
HDMI_SWING: length 1.4
  TOP w0.121: U11.34 68.51,36.76 v1(68.58,36.83)
  BOTTOM w0.121: R148.1 68.45,36.7 v1(68.58,36.83)
HDMI_TX0+: length 32
  TOP w0.095: U11.40 67.86,39.74 69.11,39.74 71.24,37.62 72,37.62 72.76,36.86 74.9,36.86 75.32,36.44 75.32,35.69 v1(74.93,35.31) 74.81,35.43 D6.2
  LYR4 w0.102: v1(77.47,25.91) 77.47,26.24 77.09,26.62 77.09,27.86 77.72,28.5 78.49,28.5 78.61,28.63 78.61,28.83 78.49,28.96 77.34,28.96 77.04,29.26 77.04,29.72 77.34,30.02 78.49,30.02 78.61,30.15 78.61,30.35 78.49,30.48 77.34,30.48 77.04,30.79 77.04,31.24 77.34,31.55 78.49,31.55 78.61,31.67 78.61,31.83 75.14,35.31 v1(74.93,35.31)
  BOTTOM w0.095: P6.9 78.65,24.95 77.91,25.68 77.7,25.68 v1(77.47,25.91)
HDMI_TX0-: length 32.1
  TOP w0.095: U11.39 68.21,39.25 68.42,39.47 68.99,39.47 71.12,37.34 71.88,37.34 72.64,36.58 74.79,36.58 74.93,36.43 v1(74.93,36.07) 74.79,35.92 D6.1
  LYR4 w0.102: v1(74.93,36.07) 74.93,36.54 75.04,36.65 75.21,36.65 75.32,36.54 75.32,35.56 78.92,31.96 78.92,31.54 78.62,31.24 77.47,31.24 77.34,31.11 77.34,30.91 77.47,30.78 78.61,30.78 78.92,30.48 78.92,30.02 78.61,29.72 77.47,29.72 77.34,29.59 77.34,29.39 77.47,29.26 78.61,29.26 78.92,28.96 78.92,28.5 78.61,28.19 77.85,28.19 77.39,27.74 77.39,26.75 v1(78.23,25.91)
  BOTTOM w0.095: v1(78.23,25.91) 78.22,25.9 78.22,25.76 78.76,25.23 79.25,25.23 79.38,25.35 P6.11
HDMI_TX1+: length 32.1
  TOP w0.095: D7.5 74.79,38.37 v1(74.93,38.23) 74.93,37.86 74.81,37.74 72.76,37.74 72.12,38.38 71.74,38.38 69.09,41.03 68.52,41.03 68.3,41.25 U11.43
  LYR4 w0.102: v1(74.93,38.23) 74.93,37.19 75.03,37.08 75.21,37.08 75.31,37.19 75.31,38.56 75.44,38.68 75.74,38.68 76.71,37.72 76.71,35.38 79.71,32.39 79.71,27.23 82.32,24.61 82.32,24.45 82.22,24.35 v1(82.04,24.35)
  BOTTOM w0.095: P6.6 v1(82.04,24.35)
HDMI_TX1-: length 32.1
  TOP w0.095: D7.4 74.81,38.87 v1(74.93,38.99) 75.32,38.6 75.32,37.85 74.93,37.47 72.64,37.47 72.01,38.1 71.63,38.1 68.97,40.76 U11.42
  LYR4 w0.102: v1(74.93,38.99) 75.87,38.99 77.01,37.85 77.01,35.51 80.01,32.51 80.01,27.36 82.8,24.56 v1(82.8,24.35)
  BOTTOM w0.095: P6.8 82.4,24.75 v1(82.8,24.35)
HDMI_TX2+: length 32.1
  TOP w0.095: v1(72.14,39.75) 72.26,39.87 D7.2 74.67,39.87 75.06,40.26 75.06,41.04 74.66,41.43 69.97,41.43 69.36,42.03 68.45,42.03 68.23,42.25 U11.45
  LYR4 w0.102: v1(72.14,39.75) 74.04,37.85 74.04,34.75 75.13,33.66 75.13,28.37 76.17,27.33 76.17,26.14 v1(75.95,25.91)
  BOTTOM w0.095: v1(75.95,25.91) 76.86,24.99 77.48,24.99 78.67,23.81 79.22,23.81 79.28,23.75 P6.3
HDMI_TX2-: length 32.1
  TOP w0.095: v1(72.14,40.51) 72.28,40.37 D7.1 74.66,40.37 74.78,40.49 74.78,40.92 74.55,41.15 69.85,41.15 69.24,41.76 U11.44
  LYR4 w0.102: v1(76.71,25.91) 76.48,26.14 76.48,27.46 75.44,28.5 75.44,33.78 74.35,34.87 74.35,37.97 72.64,39.67 72.64,40.79 72.54,40.89 72.24,40.89 72.14,40.79 v1(72.14,40.51)
  BOTTOM w0.095: P6.5 79.28,24.15 79.22,24.09 78.78,24.09 77.6,25.27 76.98,25.27 76.71,25.54 v1(76.71,25.91)
HDMI_TXC+: length 32.1
  TOP w0.095: v1(82.8,25.95) 82.08,26.67 80.41,26.67 79.14,27.94 77.34,27.94 77.22,28.07 77.22,28.96 77.34,29.08 78.47,29.08 78.77,29.37 78.77,30.19 78.47,30.48 77.34,30.48 77.22,30.61 77.22,31.09 77.34,31.22 78.47,31.22 78.77,31.51 78.77,32.35 78.47,32.64 76.45,32.64 76.2,32.89 76.2,34.03 75.81,34.42 D6.4 70.99,34.42 69.62,35.79 69.62,38.09 68.96,38.76 U11.38
  BOTTOM w0.095: v1(82.8,25.95) 82.4,25.55 P6.12
HDMI_TXC-: length 32.1
  TOP w0.095: v1(82.04,25.95) 82.04,25.35 81.92,25.22 81.66,25.22 81.53,25.35 81.53,26.26 81.41,26.39 80.29,26.39 79.02,27.66 77.23,27.66 76.94,27.95 76.94,29.07 77.23,29.36 78.36,29.36 78.49,29.49 78.49,30.07 78.36,30.2 77.23,30.2 76.94,30.49 76.94,31.21 77.23,31.5 78.36,31.5 78.49,31.62 78.49,32.23 78.36,32.36 76.34,32.36 75.92,32.78 75.92,33.92 75.69,34.15 74.65,34.15 74.43,33.93 D6.5 72.48,33.93 72.26,34.15 70.87,34.15 69.34,35.67 69.34,37.97 68.84,38.48 68.42,38.48 68.2,38.25 U11.37
  BOTTOM w0.095: P6.14 v1(82.04,25.95)
HDMICLK_DISN: length 9.7
  TOP w0.121: v1(36.07,38.48) 37.47,38.48 39.72,36.23 U5.V17 ; Y4.1 v1(39.5,39.88)
  LYR4 w0.133: v1(39.5,39.88) 37.47,39.88 v1(36.07,38.48)
I2C0_SCL: length 83.5
  TOP w0.121: U11.52 65.75,44.99 v1(65.53,45.21) ; v1(26.92,19.56) 26.04,20.45 R3.2 ; U2.28 26.72,14.24 v1(26.92,14.03) ; v1(40.12,23.61) U5.C16
  LYR3 w0.133: v1(47.62,44.2) v1(45.09,44.2)
  LYR4 w0.133: v1(26.92,19.56) 27.56,18.92 27.56,14.67 v1(26.92,14.03) ; v1(47.62,44.2) 48.26,44.84 48.26,45.97 49.28,46.99 64.26,46.99 65.53,45.72 v1(65.53,45.21) ; v1(31.75,23.11) 32.61,23.98 32.61,36.68 35.81,39.88 35.81,42.67 37.34,44.2 v1(45.09,44.2)
  BOTTOM w0.121: v1(40.12,23.61) 39.72,23.21 39.72,21.69 39.14,21.1 37.67,21.1 36.17,22.61 32.26,22.61 v1(31.75,23.11) 31.5,22.86 U7.1 30.1,22.86 28.98,21.74 28.98,20.34 28.19,19.56 v1(26.92,19.56)
I2C0_SDA: length 86.2
  TOP w0.121: U5.C17 39.32,23.61 38.72,23.61 37.34,22.23 37.34,20.83 36.58,20.07 36.45,20.07 v1(36.07,19.68) ; U2.27 26.48,13.84 v1(26.92,13.4) ; R4.2 v1(26.99,20.57) ; U11.51 66.25,45.13 v1(66.17,45.21)
  LYR3 w0.133: v1(36.07,19.68) 34.8,19.68 33.27,21.21 27.62,21.21 v1(26.99,20.57)
  LYR4 w0.133: v1(66.17,45.21) 65.76,44.81 65.3,44.81 65.13,44.98 65.13,45.49 63.88,46.74 50.29,46.74 49.4,45.85 49.4,44.32 40.89,35.81 39.62,35.81 37.72,33.91 36.45,33.91 36.07,33.53 36.07,24.38 36.2,24.25 36.2,22.87 35.56,22.23 35.56,20.19 v1(36.07,19.68) ; v1(26.92,13.4) 27.81,14.29 27.81,19.75 v1(26.99,20.57)
  BOTTOM w0.121: v1(26.99,20.57) 26.42,20 26.42,19.3 26.67,19.05 28.32,19.05 29.34,20.07 30.48,20.07 30.82,20.41 U7.3
I2C1_SCL: length 22.2
  TOP w0.121: U5.A16 v1(40.12,22.01)
  LYR4 w0.133: P9.17 41.27,3.17 41.27,8.76 41.91,9.4 41.91,12.83 41.4,13.34 41.4,20.32 40.12,21.6 v1(40.12,22.01)
I2C1_SDA: length 20.6
  TOP w0.121: U5.B16 v1(40.12,22.81)
  LYR4 w0.133: v1(40.12,22.81) 39.71,22.4 39.71,21.5 41.15,20.07 41.15,13.08 41.66,12.57 41.66,9.65 41.02,9.02 41.02,5.46 P9.18
I2C2_SCL: length 31.8
  TOP w0.121: P9.19 41.27,3.17 41.27,4.83 40.51,5.59 36.96,5.59 v1(36.07,6.48) ; v1(35.56,23.62) 37.72,23.62 38.51,24.41 39.32,24.41 U5.D17
  LYR4 w0.133: v1(35.56,23.62) 35.56,22.99 35.05,22.48 35.05,7.49 v1(36.07,6.48)
I2C2_SDA: length 29.5
  TOP w0.121: v1(36.83,6.48) 37.34,5.97 40.64,5.97 42.16,4.45 P9.20 ; U5.D18 38.4,24.81 37.47,23.88 36.07,23.88 v1(35.56,24.38)
  LYR4 w0.133: v1(35.56,24.38) 35.97,23.98 35.97,23.01 35.31,22.35 35.31,10.54 36.83,9.02 v1(36.83,6.48)
JTAG_EMU0: length 25.6
  TOP w0.121: v1(34.29,11.75) 34.42,11.87 R23.2 ; v1(41.72,23.61) U5.C14
  LYR3 w0.133: v1(42.42,15.75) 38.61,15.75 38.35,15.49 34.86,15.49 v1(34.29,14.92)
  LYR4 w0.133: v1(34.29,14.92) 33.88,14.52 33.88,12.15 v1(34.29,11.75) ; v1(42.42,15.75) 42.93,16.26 42.93,20.07 41.59,21.4 41.59,23.48 v1(41.72,23.61)
  BOTTOM w0.121: P2.13 v1(34.29,14.92)
JTAG_EMU1: length 15.5
  TOP w0.121: R24.2 36.26,15.11 v1(36.07,14.92) ; U5.B14 41.72,22.81 41.72,22.16 40.77,21.21 39.75,21.21 38.59,20.05 38.59,16.53 39.88,15.24 v1(39.88,14.92)
  BOTTOM w0.121: v1(36.07,14.92) P2.14 v1(39.88,14.92)
JTAG_TCK: length 24.5
  TOP w0.121: U5.A12 43.72,22.26 43.4,21.94 43.4,21.94 42.73,21.27 42.35,21.27 40.39,19.3 40.39,15.88 40.89,15.37 40.89,12.19 v1(41.15,11.94)
  LYR3 w0.133: v1(34.29,12.38) 34.73,11.94 36.32,11.94 36.83,11.43 40.64,11.43 v1(41.15,11.94)
  BOTTOM w0.121: P2.11 34.1,13.65 34.29,13.46 v1(34.29,12.38) P2.9
JTAG_TDI: length 24.1
  TOP w0.121: v1(39.88,10.92) 40.51,10.92 41.02,11.43 41.4,11.43 41.66,11.68 41.66,12.7 41.27,13.08 41.27,15.59 40.8,16.06 40.8,19.21 42.51,20.92 42.87,20.92 44.12,22.17 44.12,22.81 U5.B11
  BOTTOM w0.121: v1(39.88,10.92) 39.88,10.79 39.56,10.48 36.26,10.48 34.35,8.57 P2.3
JTAG_TDO: length 24.3
  TOP w0.121: v1(41.15,10.92) 41.4,10.92 42.04,11.56 42.04,12.83 41.66,13.21 41.66,15.81 41.15,16.32 41.15,19.05 42.54,20.44 42.54,20.45 43.56,20.45 44.2,21.08 44.2,21.72 44.52,22.04 U5.A11
  LYR3 w0.133: v1(41.15,10.92) 40.64,10.41 40.64,10.16 40.13,9.65 36.32,9.65 34.86,11.11 v1(34.29,11.11)
  BOTTOM w0.121: P2.7 v1(34.29,11.11)
JTAG_TMS: length 29.2
  TOP w0.121: U5.C11 v1(44.12,23.61) ; v1(45.09,15.75) 44.64,15.3 44.64,13.53 44.2,13.08 v1(44.2,8.89)
  LYR4 w0.133: v1(45.09,15.75) 44.58,16.26 44.58,19.18 45.09,19.68 45.09,22.64 v1(44.12,23.61)
  BOTTOM w0.121: v1(44.2,8.89) 43.69,9.4 41.66,9.4 40.2,7.94 35.5,7.94 34.86,7.3 P2.1
JTAG_TRSTN: length 25.6
  TOP w0.121: v1(36.07,7.3) 36.64,7.3 36.83,7.49 R25.1 ; U5.B10 44.92,22.81 44.92,22.06 44.45,21.59 44.45,20.95 43.69,20.19 42.67,20.19 41.4,18.92 41.4,16.51 41.91,16 41.91,13.46 42.55,12.83 v1(42.55,8.89)
  BOTTOM w0.121: v1(36.07,7.3) P2.2 40.07,7.3 41.66,8.89 v1(42.55,8.89)
LCD_DATA0: length 41
  TOP w0.121: U11.15 58.7,36.76 57.91,35.97 57.91,35.56 v1(57.15,34.8) 57.02,34.67 54.36,34.67 53.3,33.61 U5.R1 ; R95.1 v1(71.75,48.26) ; C173.1 P8.45
  LYR3 w0.133: v1(57.15,34.8) 57.91,35.56 57.91,35.81 58.29,36.2 66.04,36.2 71.25,41.4 71.25,47.12 71.75,47.62 v1(71.75,48.26)
  BOTTOM w0.121: P8.45 74.3,48.9 72.39,48.9 v1(71.75,48.26) R95.1
LCD_DATA1: length 47.7
  TOP w0.121: R94.1 v1(70.8,48.26) 72.01,49.47 72.01,50.93 72.52,51.44 74.3,51.44 P8.46 ; U11.13 58.2,37.76 57.91,37.47 57.91,36.32 v1(57.15,35.56) 56.64,35.05 54.23,35.05 53.19,34.01 52.11,34.01 51.72,33.62 U5.R2
  LYR3 w0.133: v1(57.15,35.56) 58.17,36.58 65.79,36.58 70.36,41.15 70.36,47.12 70.8,47.56 v1(70.8,48.26)
  BOTTOM w0.121: v1(70.8,48.26) R94.1 ; P8.46 76.58,51.69 76.58,49.15 75.56,48.13 C171.1
LCD_DATA2: length 40.3
  TOP w0.121: R75.1 73.66,49.53 P8.43 ; R93.1 v1(69.85,48.26) ; v1(58.42,38.23) 58.45,38.25 U11.12 ; v1(51.32,34.01) U5.R3
  LYR3 w0.133: v1(69.85,48.26) 69.85,47.62 69.34,47.12 69.34,42.04 66.04,38.73 58.93,38.73 v1(58.42,38.23)
  BOTTOM w0.121: P8.43 71.75,48.9 70.48,48.9 v1(69.85,48.26) R93.1 ; v1(51.32,34.01) 51.79,34.01 53.47,35.69 53.47,38.1 C172.1 56.77,39.88 v1(58.42,38.23)
LCD_DATA3: length 44.9
  TOP w0.121: U11.11 58.53,38.76 v1(58.42,38.86) ; R92.1 v1(68.9,48.26) 69.53,48.9 70.8,48.9 71.5,49.59 71.5,51.18 P8.44 ; v1(50.52,34.01) U5.R4
  LYR3 w0.133: v1(58.42,38.86) 59.56,40.01 66.67,40.01 69.09,42.42 69.09,44.83 68.33,45.59 68.33,46.74 68.9,47.31 v1(68.9,48.26)
  BOTTOM w0.121: v1(58.42,38.86) 56.64,40.64 56.64,41.15 55.63,42.16 53.72,42.16 53.47,41.91 53.47,40.39 C170.1 53.21,39.12 53.21,36.14 51.49,34.41 50.92,34.41 v1(50.52,34.01) ; v1(68.9,48.26) R92.1
LCD_DATA4: length 32
  TOP w0.121: R91.1 v1(67.94,48.26) ; U5.T1 53.08,34.41 53.85,35.18 53.85,36.2 55.5,37.85 C169.1 56.9,37.85 v1(57.15,38.1) 57.15,38.61 57.85,39.31 58.62,39.31 58.67,39.25 U11.10
  LYR3 w0.133: v1(57.15,38.1) 57.15,38.35 61.21,42.42 66.04,42.42 68.08,44.46 68.08,47.62 67.94,47.76 v1(67.94,48.26)
  BOTTOM w0.121: P8.41 69.22,48.9 68.58,48.9 v1(67.94,48.26) R91.1
LCD_DATA5: length 37.2
  TOP w0.121: U11.7 58.54,40.76 57.66,39.88 C163.1 v1(56.52,39.12) 56.01,38.61 54.36,38.61 53.59,37.85 53.59,35.43 52.97,34.81 52.12,34.81 U5.T2 ; R90.1 v1(66.99,48.26) 67.63,48.9 68.26,48.9 69.22,49.85 69.22,51.44 P8.42
  LYR3 w0.133: v1(66.99,48.26) 66.99,47.82 67.84,46.96 67.84,44.73 66.04,42.93 61.21,42.93 57.4,39.12 v1(56.52,39.12)
  BOTTOM w0.121: v1(66.99,48.26) R90.1
LCD_DATA6: length 34.1
  TOP w0.121: v1(51.32,34.81) U5.T3 ; v1(57.66,40.64) 58.27,41.25 U11.6 ; R89.1 v1(66.04,48.26)
  LYR3 w0.133: v1(66.04,48.26) 65.09,47.31 65.09,44.39 63.88,43.18 60.96,43.18 58.42,40.64 v1(57.66,40.64)
  BOTTOM w0.121: R89.1 v1(66.04,48.26) P8.39 ; v1(57.66,40.64) 55.12,43.18 53.72,43.18 53.21,42.67 53.21,40.39 C162.1 52.07,39.24 52.07,35.56 v1(51.32,34.81)
LCD_DATA7: length 42.4
  TOP w0.121: U11.3 58.08,42.76 v1(57.66,43.18) ; P8.40 66.67,51.44 66.67,49.85 v1(65.09,48.26) R88.1 ; v1(50.52,34.81) U5.T4
  LYR3 w0.133: v1(57.66,43.18) 57.02,43.81 57.02,48.51 57.53,49.02 58.17,49.02 58.93,49.78 58.93,50.67 59.82,51.56 63.5,51.56 64.39,50.67 64.39,49.02 65.09,48.32 v1(65.09,48.26)
  BOTTOM w0.121: v1(65.09,48.26) R88.1 ; v1(50.52,34.81) 51.18,35.47 51.18,38.23 50.93,38.48 50.93,39.37 C161.1 50.93,40.39 50.93,41.66 52.7,43.43 57.4,43.43 v1(57.66,43.18)
LCD_DATA8: length 32.8
  TOP w0.121: U5.U1 52.86,35.21 53.34,35.69 53.34,37.97 54.74,39.37 54.74,40.39 C160.1 55.24,41.78 57.15,43.69 57.91,43.69 v1(58.42,43.18) 58.49,43.25 U11.2 ; R87.1 v1(64.14,48.26)
  LYR3 w0.133: v1(64.14,48.26) 64.14,50.55 63.37,51.31 59.94,51.31 59.18,50.55 59.18,49.66 57.91,48.39 57.91,43.69 v1(58.42,43.18)
  BOTTOM w0.121: R87.1 v1(64.14,48.26) 64.14,48.9 P8.37
LCD_DATA9: length 30.2
  TOP w0.121: U5.U2 51.96,35.21 52.36,35.61 52.75,35.61 53.09,35.94 53.09,38.1 53.98,38.99 C157.1 54.48,40.39 54.48,41.53 56.9,43.94 v1(58.42,43.94) 58.61,43.76 U11.1 ; R86.1 v1(63.18,48.26) 63.18,48.9 64.14,49.85 64.14,51.44 P8.38
  LYR3 w0.133: v1(63.18,48.26) 63.18,48.32 62.36,49.15 59.56,49.15 58.93,48.51 58.93,44.45 v1(58.42,43.94)
  BOTTOM w0.121: v1(63.18,48.26) R86.1
LCD_DATA10: length 30
  TOP w0.121: R85.1 v1(62.23,48.26) 62.23,49.21 61.59,49.85 61.59,51.44 P8.36 ; v1(60.33,45.72) 59.75,45.14 U11.64 56.67,44.36 55.75,43.43 C156.1 55.24,42.8 54.61,42.16 53.72,42.16 53.47,41.91 53.47,38.86 52.07,37.47 52.07,36.22 52.12,36.17 52.12,35.85 51.88,35.61 51.32,35.61 U5.U3
  LYR3 w0.133: v1(60.33,45.72) 60.33,47.37 59.82,47.88 59.82,48.51 60.2,48.9 61.01,48.9 61.01,48.9 61.59,48.9 v1(62.23,48.26)
  BOTTOM w0.121: v1(62.23,48.26) R85.1
LCD_DATA11: length 32.4
  TOP w0.121: U5.U4 50.52,35.61 50.52,37.06 51.94,38.48 51.94,41.91 v1(52.7,42.67) C168.1 ; R84.1 v1(59.37,48.26) 59.37,49.21 59.05,49.53 59.05,51.44 P8.34 ; v1(61.47,45.21) 61.75,44.93 U11.60
  LYR3 w0.133: v1(52.7,42.67) 53.21,43.18 56.9,43.18 57.4,42.67 59.82,42.67 61.47,44.32 v1(61.47,45.21) 60.07,45.21 59.82,45.47 59.82,47.12 59.37,47.56 v1(59.37,48.26)
  BOTTOM w0.121: v1(59.37,48.26) R84.1
LCD_DATA12: length 26.9
  TOP w0.121: U5.V2 51.72,37.5 53.21,38.99 53.21,42.04 53.47,42.29 53.47,43.94 C167.1 53.98,44.96 54.23,45.21 55.63,45.21 v1(56.13,44.7) ; U11.59 62.25,45.06 v1(62.1,45.21) ; R83.1 v1(61.28,48.26)
  LYR3 w0.133: v1(62.1,45.21) 61.28,46.04 v1(61.28,48.26)
  BOTTOM w0.121: R83.1 v1(61.28,48.26) 61.28,48.58 P8.35 ; v1(56.13,44.7) 61.59,44.7 v1(62.1,45.21)
LCD_DATA13: length 30.4
  TOP w0.121: U11.58 62.75,45.2 v1(62.74,45.21) ; v1(55.24,45.72) 54.1,45.72 53.21,44.83 53.21,42.55 52.83,42.16 52.58,42.16 52.2,41.78 52.2,40.39 C166.1 52.7,38.86 50.92,37.08 U5.V3 ; R82.1 v1(60.33,48.26)
  LYR3 w0.133: v1(62.74,45.21) 61.72,46.23 61.72,48.39 61.45,48.67 61.11,48.67 61.1,48.66 60.73,48.66 v1(60.33,48.26)
  LYR4 w0.133: v1(62.74,45.21) 61.72,46.23 55.75,46.23 v1(55.24,45.72)
  BOTTOM w0.121: R82.1 v1(60.33,48.26) P8.33
LCD_DATA14: length 42
  TOP w0.121: v1(63.37,45.21) 63.25,45.05 U11.57 ; U5.V4 50.12,37.04 50.96,37.88 50.96,41.82 51.94,42.8 51.94,46.48 52.96,47.5 C165.1 55.24,48.26 55.75,48.77 56.96,48.77 v1(57.47,48.26) R81.1
  LYR4 w0.133: v1(57.47,48.26) 58.1,48.9 66.17,48.9 66.55,48.51 66.55,47.75 68.08,46.22 68.08,44.84 67.44,44.2 64.39,44.2 v1(63.37,45.21)
  BOTTOM w0.121: P8.31 57.78,49.21 57.47,48.9 v1(57.47,48.26) R81.1
LCD_DATA15: length 46.8
  TOP w0.121: R80.1 v1(58.42,48.26) 57.78,48.9 57.47,48.9 56.52,49.85 56.52,51.44 P8.32 ; v1(49.72,34.81) U5.T5 ; U11.56 63.75,44.95 v1(64.01,45.21)
  LYR4 w0.133: v1(64.01,45.21) 64.77,44.45 67.31,44.45 67.84,44.98 67.84,45.82 65.91,47.75 58.93,47.75 v1(58.42,48.26)
  BOTTOM w0.121: v1(64.01,45.21) 63.25,44.45 57.91,44.45 57.53,44.07 52.96,44.07 50.67,41.78 50.67,40.39 C164.1 49.72,39.43 v1(49.72,34.81) ; v1(58.42,48.26) R80.1
LCD_DE: length 31.6
  TOP w0.121: v1(61.09,34.8) 61.25,34.96 U11.20 ; R48.2 49.66,41.4 49.66,41.78 50.8,42.93 v1(50.8,45.21)
  LYR4 w0.133: v1(50.8,45.21) 51.18,44.83 53.47,44.83 57.02,41.27 57.6,41.27 58.06,40.81 59.18,39.69 59.18,36.7 v1(61.09,34.8)
  BOTTOM w0.121: v1(50.8,45.21) 50.8,46.61 53.98,49.78 53.98,51.44 55.24,52.7
LCD_HSYNC: length 28.4
  TOP w0.121: R47.2 51.44,41.78 52.2,42.55 52.2,45.72 v1(52.7,46.23) ; U11.22 62.25,34.9 v1(62.36,34.8)
  LYR4 w0.133: v1(62.36,34.8) 60.2,36.96 60.2,40.77 58.23,42.74 57.09,42.74 53.59,46.23 v1(52.7,46.23)
  BOTTOM w0.121: v1(52.7,46.23) 52.7,47.62 55.24,50.16
LCD_PCLK: length 20.1
  TOP w0.121: P8.28 51.44,51.44 51.44,49.34 50.8,48.7 50.8,46.35 v1(50.16,45.72) R45.2 ; v1(57.66,42.25) U11.4
  LYR4 w0.133: v1(57.66,42.25) 57.06,42.25 53.72,45.59 52.45,45.59 51.82,46.23 50.67,46.23 v1(50.16,45.72)
LCD_VSYNC: length 23.6
  TOP w0.121: U11.21 61.75,34.83 v1(61.72,34.8) ; P8.27 52.7,49.15 51.44,47.88 v1(51.44,45.72) R46.2
  LYR4 w0.133: v1(61.72,34.8) 59.69,36.83 59.69,39.75 57.78,41.66 57.15,41.66 53.59,45.21 51.94,45.21 v1(51.44,45.72)
LCDDE: length 6.9
  TOP w0.121: v1(48.92,34.01) U5.R6 ; R48.1 v1(50.16,39.12)
  LYR3 w0.121: 49.32,35.18 49.32,34.41 v1(48.92,34.01)
  LYR3 w0.133: 49.32,35.18 49.53,35.39 49.53,38.48 v1(50.16,39.12)
LCDPCLK: length 8.1
  TOP w0.121: U5.V5 49.32,37.21 49.66,37.55 49.66,38.48 49.28,38.86 49.28,41.91 50.16,42.8 R45.1
LCDVHYNC: length 7.1
  TOP w0.121: v1(49.72,34.01) U5.R5 ; v1(51.44,39.12) R47.1
  LYR3 w0.121: 50.12,35.13 50.12,34.41 v1(49.72,34.01)
  LYR3 w0.133: 50.12,35.13 51.44,36.45 v1(51.44,39.12)
LCDVSYNC: length 9.1
  TOP w0.121: U5.U5 49.72,35.61 49.72,37.02 50.71,38.01 50.71,42.08 51.44,42.8 R46.1
LDO_PGOOD: length 35.9
  TOP w0.121: U5.B5 v1(49.72,22.81) ; v1(20.83,19.62) 21.46,18.99 U2.46
  LYR3 w0.133: v1(20.83,19.62) 22.67,21.46 33.53,21.46 34.9,20.09 37.57,20.09 38.86,18.8 43.18,18.8 43.81,19.43 48.64,19.43 49.72,20.51 v1(49.72,22.81)
LEDAA: length 1.8
  TOP w0.121: R72.2 D2.2
LEDAC: length 11.9
  TOP w0.121: Q1.6 12.37,47.83 11.68,48.51 2.86,48.51 2.35,48.01 D2.1
LEDBA: length 2.3
  TOP w0.121: D3.2 4,45.53 4.83,46.35 R73.2
LEDBC: length 17.6
  TOP w0.121: Q1.3 13.67,44.66 13.34,44.32 12.06,44.32 11.68,44.7 11.68,47.37 10.79,48.26 8.64,48.26 8.13,47.75 8.13,47.12 7.84,46.83 4.79,46.83 4.32,46.35 2.54,46.35 2.35,46.16 D3.1
LEDCA: length 3
  TOP w0.121: D4.2 4,43.62 4.95,44.58 4.95,45.15 5.21,45.4 R74.2
LEDCC: length 9.1
  TOP w0.121: Q2.6 8.62,47.11 8.26,46.74 8.26,46.23 7.91,45.88 5.24,45.88 4.7,45.34 4.7,44.7 4.45,44.45 2.54,44.45 2.35,44.26 D4.1
LEDDA: length 4
  TOP w0.121: D5.2 4.64,41.59 4.95,41.91 4.95,43.56 R71.2
LEDDC: length 11.8
  TOP w0.121: Q2.3 10.17,44.72 9.78,44.32 8.51,44.32 7.91,44.93 5.37,44.93 5.21,44.77 5.21,44.32 4.7,43.81 4.7,42.8 4.45,42.55 2.54,42.55 2.35,42.35 D5.1
MDIO_CLK: length 14.5
  TOP w0.121: U5.M18 38.82,31.11 38.35,31.11 37.72,31.75 36.7,31.75 35.69,32.77 35.31,32.77 33.4,34.67 32.51,34.67 32,34.16 28.83,34.16 28.7,34.29 26.95,34.29 26.83,34.17 U14.17
MDIO_DATA: length 15
  TOP w0.121: U14.16 28.04,32.87 28.32,33.15 28.83,33.15 29.34,33.66 R119.2 30.45,33.18 31.97,33.18 32.26,33.46 32.26,33.91 32.66,34.31 33.38,34.31 35.18,32.51 35.56,32.51 36.58,31.5 37.59,31.5 38.28,30.81 39.32,30.81 U5.M17
MII1_COL: length 24.2
  TOP w0.121: v1(40.12,27.61) U5.H16
  LYR3 w0.133: v1(40.12,27.61) 39.79,27.94 32.64,27.94 32.51,27.81 32.51,26.67 32.38,26.54 29.84,26.54 29.72,26.42 29.72,25.27 29.84,25.15 30.86,25.15 30.99,25.27 30.99,25.91 31.11,26.04 v1(31.75,26.04)
  BOTTOM w0.121: R138.1 31.43,32.26 31.84,32.26 32.15,31.95 32.15,30.84 32.51,30.48 32.51,26.8 v1(31.75,26.04)
MII1_CRS_DV: length 25.6
  TOP w0.121: R139.1 v1(31.75,32.7) ; v1(36.83,28.41) 39.32,28.41 U5.H17
  BOTTOM w0.121: v1(31.75,32.7) 31.75,33.05 31.85,33.15 32.3,33.15 32.4,33.05 32.4,31.09 32.5,30.99 34.95,30.99 35.05,30.89 35.05,30.77 34.95,30.67 32.96,30.67 32.86,30.57 32.86,30.45 32.96,30.35 35.81,30.35 36.07,30.1 36.07,24.49 36.17,24.38 36.33,24.38 36.43,24.49 36.43,28.01 v1(36.83,28.41)
MII1_REFCLK: length 18.3
  TOP w0.121: R124.1 v1(31.75,26.99) 31.94,26.8 32.18,26.8 32.26,26.87 32.26,27.1 32.33,27.18 32.62,27.18 32.83,26.97 33.32,26.97 33.42,26.87 33.42,26.12 33.32,26.02 32.59,26.02 32.51,25.94 32.51,25.73 32.59,25.65 33.32,25.65 33.4,25.58 33.4,25.35 33.32,25.27 32.59,25.27 32.51,25.2 32.51,24.97 32.59,24.89 33.71,24.89 33.78,24.97 33.78,25.32 33.86,25.4 34.09,25.4 34.16,25.48 34.16,25.7 34.09,25.78 33.86,25.78 33.78,25.86 33.78,26.09 33.86,26.16 34.98,26.16 35.05,26.24 35.05,26.47 34.98,26.54 33.86,26.54 33.78,26.62 33.78,26.85 33.86,26.92 34.98,26.92 35.05,27 35.05,27.23 34.98,27.3 33.86,27.3 33.78,27.38 R28.2
  BOTTOM w0.121: R140.1 30.99,26.42 31.11,26.54 31.62,26.54 31.75,26.67 v1(31.75,26.99)
MII1_RXCLK: length 23.8
  TOP w0.121: v1(31.75,30.8) 31.75,30.45 31.85,30.35 32.19,30.35 32.51,30.04 32.51,29.34 32.64,29.21 33.34,29.21 33.46,29.34 33.46,31.78 33.36,31.88 33.19,31.88 33.08,31.78 33.08,30.58 32.98,30.48 32.87,30.48 32.77,30.58 32.77,32.4 32.66,32.51 32.28,32.51 32.15,32.63 32.15,32.77 32.26,32.87 33.29,32.87 33.42,33 33.42,33.42 33.53,33.53 33.78,33.53 35.05,32.26 35.43,32.26 36.45,31.24 37.47,31.24 38.3,30.41 U5.L18
  BOTTOM w0.121: R131.1 30.99,27.3 31.11,27.43 31.88,27.43 32.26,27.81 32.26,30.29 v1(31.75,30.8)
MII1_RXD0: length 24.3
  TOP w0.121: R128.1 31.75,31.56 v1(31.75,31.75) ; U5.M16 40.12,31.61 v1(39.32,31.61)
  LYR3 w0.133: v1(39.32,31.61) 38.91,32.02 32.64,32.02 32.36,32.3 31.37,32.3 31.24,32.42 31.24,33.02 31.37,33.15 32.28,33.15 32.38,33.25 32.38,34.06 32.28,34.16 31.37,34.16 31.24,34.29 31.24,34.92 31.37,35.05 32.28,35.05 32.38,35.15 32.38,35.97 32.28,36.07 30.96,36.07 30.86,35.97 30.86,31.85 30.96,31.75 v1(31.75,31.75)
MII1_RXD1: length 24.1
  TOP w0.121: R127.1 v1(31.75,29.84) ; U5.L15 v1(40.92,30.01)
  LYR3 w0.121: v1(40.92,30.01) 40.52,29.61 39.75,29.61
  LYR3 w0.133: v1(31.75,29.84) 31.5,30.1 30.23,30.1 30.1,30.23 30.1,31.88 29.97,32 29.74,32 29.62,31.88 29.62,29.82 30.1,29.34 31.88,29.34 32.26,29.72 32.26,30.23 32.89,30.86 32.89,31.14 32.99,31.24 33.17,31.24 33.27,31.14 33.27,30.71 33.38,30.61 33.55,30.61 33.66,30.71 33.66,31.14 33.76,31.24 33.93,31.24 34.04,31.14 34.04,30.71 34.14,30.61 34.32,30.61 34.42,30.71 34.42,31.14 34.52,31.24 34.7,31.24 34.8,31.14 34.8,30.71 34.9,30.61 35.08,30.61 35.15,30.68 35.15,31.14 35.26,31.24 37.19,31.24 38.82,29.61 39.75,29.61
MII1_RXD2: length 24.1
  TOP w0.121: U5.L16 v1(40.92,30.81) ; R126.1 30.99,29.24 31.09,29.34 31.39,29.34 31.5,29.24 31.5,28.99 31.6,28.89 31.78,28.89 31.88,28.99 31.88,29.36 31.98,29.46 32.16,29.46 32.26,29.36 32.26,28.99 32.36,28.89 33.66,28.89 33.78,29.02 33.78,32.03 33.68,32.13 33.12,32.13 33.02,32.23 33.02,32.41 33.12,32.51 33.55,32.51 33.66,32.61 33.66,32.92 33.76,33.02 33.94,33.02 34.69,32.27 34.69,30.85 34.8,30.73 34.96,30.73 35.07,30.85 35.07,31.91 35.17,32.01 35.31,32.01 35.58,31.74 35.58,31.36 35.68,31.26 36.07,31.26 36.2,31.13 36.2,30.92 36.07,30.8 v1(35.56,30.8)
  BOTTOM w0.121: v1(40.92,30.81) U5.L16 39.95,30.41 39.37,29.83 39.37,29.59 39.12,29.34 37.14,29.34 36.45,30.03 36.45,30.61 36.26,30.8 v1(35.56,30.8)
MII1_RXD3: length 24.4
  TOP w0.121: U5.L17 39.32,30.01 37.69,30.01 37.59,30.11 37.59,30.76 37.49,30.86 37.31,30.86 37.23,30.78 37.23,30.2 37.13,30.1 36.86,30.1 36.6,30.35 36.35,30.35 36.09,30.1 35.94,30.1 35.69,30.35 34.9,30.35 34.8,30.25 34.8,28.93 34.9,28.83 35.08,28.83 35.18,28.93 35.18,29.34 35.28,29.45 35.36,29.45 35.47,29.34 35.47,28.93 35.57,28.83 35.76,28.83 35.86,28.93 35.86,29.34 35.96,29.45 36.09,29.45 36.18,29.36 36.18,28.66 36.09,28.57 34.52,28.57 34.42,28.68 34.42,32.16 34.32,32.26 34.14,32.26 34.04,32.16 34.04,28.7 33.91,28.57 31.62,28.57 R125.1
MII1_RXDV: length 25.8
  TOP w0.121: U5.J17 v1(40.12,29.21)
  LYR3 w0.133: v1(18.73,33.66) 19.81,33.66 20.94,32.52 21.58,32.52 24.77,29.34 29.59,29.34 29.84,29.08 32,29.08 32.61,29.69 32.61,30.07 32.89,30.35 37.59,30.35 38.73,29.21 v1(40.12,29.21)
  BOTTOM w0.121: v1(18.73,33.66) R129.1
MII1_RXERR: length 24.3
  TOP w0.121: v1(33.02,29.84) 33.02,29.88 32.39,30.51 32.39,32.16 32.29,32.26 31.5,32.26 R133.1 ; U5.J15 v1(40.92,29.21)
  LYR3 w0.121: v1(40.92,29.21) 40.52,28.81 39.86,28.81
  LYR3 w0.133: v1(33.02,29.84) 33.02,28.57 33.15,28.45 33.55,28.45 33.66,28.55 33.66,30 33.76,30.1 33.93,30.1 34.04,30 34.04,28.55 34.14,28.45 34.44,28.45 34.54,28.55 34.54,30 34.65,30.1 34.82,30.1 34.92,30 34.92,28.55 35.03,28.45 35.2,28.45 35.31,28.55 35.31,29.24 35.41,29.34 35.59,29.34 35.69,29.24 35.69,28.55 35.79,28.45 35.94,28.45 36.07,28.57 36.07,29.87 36.17,29.97 37.47,29.97 37.57,29.87 37.57,28.96 37.72,28.81 39.86,28.81
MII1_TXCLK: length 22.6
  TOP w0.121: U5.K18 37.47,29.61 37.23,29.84 v1(35.56,29.84)
  LYR5_PWR w0.121: v1(35.56,29.84) 36.07,30.35 36.07,32.13 33.4,34.8 32.51,34.8 v1(31.75,35.56)
  BOTTOM w0.121: v1(31.75,35.56) 31.75,36.32 30.99,37.08 27.18,37.08 27.05,36.96 27.05,36.45 27.18,36.32 30.73,36.32 30.99,36.07 R134.1
MII1_TXD0: length 28.1
  TOP w0.121: U14.22 24.33,34.41 v1(24.13,34.61) ; v1(28.45,27.94) 28.92,27.46 32,27.46 32.15,27.61 32.15,28.21 32.26,28.32 36.35,28.32 36.43,28.4 36.43,29.38 36.53,29.48 37.19,29.48 37.47,29.21 39.32,29.21 U5.K17
  LYR4 w0.133: v1(28.45,27.94) 27.94,28.45 24.38,28.45 22.35,30.48 22.35,34.8 22.61,35.05 23.69,35.05 v1(24.13,34.61)
MII1_TXD1: length 28.1
  TOP w0.121: U14.23 23.83,34.27 v1(23.5,34.61) ; v1(40.12,30.01) U5.K16
  LYR3 w0.133: v1(40.12,30.01) 38.82,30.01 37.34,31.5 32.64,31.5 32.16,31.01 32.16,30.63 31.92,30.39 30.48,30.39 30.35,30.52 30.35,32.98 30.23,33.11 23.62,33.11 23.5,33.23 23.5,33.41 23.62,33.53 25.78,33.53 25.91,33.66 25.91,33.91 25.78,34.04 23.62,34.04 23.5,34.16 v1(23.5,34.61)
MII1_TXD2: length 28.1
  TOP w0.121: U5.K15 v1(41.72,30.01) ; U14.24 23.33,34.14 23.1,34.37 23.1,34.84 23.56,35.31 28.19,35.31 v1(28.45,35.56)
  LYR3 w0.121: v1(41.72,30.01) 41.72,30.01 41.32,30.41 39.88,30.41
  LYR3 w0.133: 39.88,30.41 38.93,30.41 37.59,31.75 32.51,31.75 32.03,31.27 30.71,31.27 30.61,31.37 30.61,36.58 30.48,36.7 28.57,36.7 28.45,36.58 v1(28.45,35.56)
MII1_TXD3: length 28.5
  TOP w0.121: U5.J18 37.08,28.81 36.83,29.06 v1(36.83,29.08) ; U14.25 22.29,32.87 21.97,33.18 21.97,33.91 21.72,34.16 20.57,34.16 20.32,34.42 20.32,36.07 20.57,36.32 29.46,36.32 30.73,35.05 33.78,35.05 v1(35.56,33.27)
  LYR5_PWR w0.121: v1(36.83,29.08) 36.32,29.59 36.32,32.51 v1(35.56,33.27)
MII1_TXEN: length 28
  TOP w0.121: v1(24.83,34.61) U14.21 ; v1(40.12,28.41) U5.J16
  LYR3 w0.133: v1(28.45,28.89) 26.9,28.89 26.8,28.79 26.8,27.53 26.9,27.43 32.13,27.43 32.26,27.56 32.26,28.07 32.38,28.19 36.2,28.19 36.32,28.32 36.32,29.46 36.45,29.59 37.24,29.59 37.34,29.49 37.34,28.51 37.44,28.41 v1(40.12,28.41)
  LYR4 w0.133: v1(24.83,34.61) 26.92,32.52 26.92,30.42 v1(28.45,28.89)
MMC0_CD: length 85.2
  TOP w0.121: R157.1 v1(71.75,44.77) ; v1(40.92,23.61) U5.C15
  LYR3 w0.133: v1(72.14,36.07) 71.5,36.7 71.5,40.89 71.75,41.15 v1(71.75,44.77)
  LYR4 w0.133: v1(60.96,12.45) 62.48,13.97 67.69,13.97 71.63,17.91 71.63,35.56 v1(72.14,36.07)
  BOTTOM w0.121: v1(60.96,12.45) 60.07,13.34 47.09,13.34 46.91,13.16 41.96,13.16 40.89,14.22 40.89,14.73 40.07,15.56 36,15.56 35.31,16.26 35.31,18.03 34.61,18.73 ; v1(40.92,23.61) 40.52,23.21 40.52,21.84 39.53,20.85 36.09,20.85 35.42,20.18 35.42,19.55 34.61,18.73 ; 34.61,18.73 P2.19 ; P10.10 71.61,44.62 v1(71.75,44.77)
MMC0_CLKO: length 82.6
  TOP w0.121: v1(31.75,20.32) 32.64,21.21 32.64,21.97 33.53,22.86 33.53,24.26 35.31,26.04 37.08,26.04 38.66,27.61 39.32,27.61 U5.G17 ; v1(83.7,31.69) 83.19,32.2 R152.2
  LYR3 w0.133: v1(83.7,31.69) 83.06,32.32 75.95,32.32 69.22,25.59 69.22,17.84 66.22,14.85 53.85,14.85 52.96,15.75 48.39,15.75 46.61,17.53 40.89,17.53 40.64,17.78 39.62,17.78 38.86,17.02 33.78,17.02 31.74,19.06 31.74,20.31 v1(31.75,20.32)
  BOTTOM w0.121: P10.5 v1(83.7,31.69)
MMC0_CMD: length 88.2
  TOP w0.121: U5.G18 38.64,27.21 37.21,25.78 35.43,25.78 33.78,24.13 33.78,22.61 32.89,21.72 32.89,20.83 v1(32.38,20.32) ; R151.2 v1(83.19,43.75)
  LYR3 w0.133: v1(83.19,43.75) 82.55,43.12 82.55,36.51 78.68,32.64 75.82,32.64 68.9,25.72 68.9,18.03 65.95,15.09 54.25,15.09 53.34,16 48.64,16 46.86,17.78 45.21,17.78 44.96,18.03 39.37,18.03 38.61,17.27 34.04,17.27 31.98,19.33 31.98,19.91 v1(32.38,20.32)
  BOTTOM w0.121: v1(83.19,43.75) 83,43.94 P10.3
MMC0_DAT0: length 70.3
  TOP w0.121: v1(82.23,31.69) R153.2 ; v1(40.12,26.81) U5.G16
  LYR3 w0.133: v1(82.23,31.69) 81.34,30.8 75.37,30.8 70.99,26.42 70.99,18.61 66.74,14.35 48.77,14.35 46.1,17.02 40.39,17.02 v1(39.88,16.51)
  LYR4 w0.133: v1(39.88,16.51) 38.35,18.03 38.35,18.46 38.35,18.47 38.35,21.34 38.1,21.58 38.1,24.99 39.92,26.81 v1(40.12,26.81)
  BOTTOM w0.121: v1(82.23,31.69) 82.3,31.62 P10.7
MMC0_DAT1: length 68.5
  TOP w0.121: v1(81.28,31.69) R154.2 ; v1(40.92,26.81) U5.G15
  LYR3 w0.133: v1(39.88,17.27) 46.35,17.27 48.13,15.49 52.58,15.49 53.47,14.61 66.48,14.61 70.48,18.61 70.48,26.42 75.5,31.43 81.03,31.43 v1(81.28,31.69)
  LYR4 w0.121: v1(40.92,26.81) 40.52,26.41 39.95,26.41 39.74,26.19
  LYR4 w0.133: 39.74,26.19 38.93,25.39 38.93,21.21 38.58,20.86 38.58,18.57 v1(39.88,17.27)
  BOTTOM w0.121: P10.8 81.6,31.37 v1(81.28,31.69)
MMC0_DAT2: length 85.3
  TOP w0.121: v1(33.02,19.56) 33.15,19.56 33.42,19.83 33.42,21.74 34.04,22.35 34.04,24 35.57,25.53 37.34,25.53 38.22,26.41 U5.F18 ; v1(81.28,43.75) R150.2
  LYR3 w0.133: v1(81.28,43.75) 81.92,43.12 81.92,37.15 78.04,33.27 75.44,33.27 70.61,28.45 69.47,28.45 68.26,27.24 68.26,18.41 66.1,16.26 63.12,16.26 62.48,15.62 56.19,15.62 55.56,16.26 54.36,16.26 51.44,19.18 44.07,19.18 43.43,18.54 34.04,18.54 v1(33.02,19.56)
  BOTTOM w0.121: P10.1 81.6,44.07 v1(81.28,43.75)
MMC0_DAT3: length 88.2
  TOP w0.121: U5.F17 39.32,26.01 38.19,26.01 37.47,25.29 35.7,25.29 34.29,23.88 34.29,22.1 33.78,21.59 33.78,19.56 33.27,19.05 32.89,19.05 v1(32.38,19.56) ; R155.2 v1(82.23,43.75)
  LYR3 w0.133: v1(32.38,19.56) 34.42,17.53 38.35,17.53 39.12,18.29 43.69,18.29 44.32,18.92 46.23,18.92 48.9,16.26 53.72,16.26 54.61,15.37 62.74,15.37 63.37,16 66.36,16 68.58,18.22 68.58,25.91 75.63,32.96 78.36,32.96 82.23,36.83 v1(82.23,43.75)
  BOTTOM w0.121: P10.2 82.3,43.81 v1(82.23,43.75)
MMC1_CLK: length 41.7
  TOP w0.121: U5.U9 46.52,35.61 46.52,36.43 46.67,36.58 46.67,39.05 45.85,39.88 45.85,49.4 P8.21
  TOP w0.203: U13.M6 v2(28.09,42.66)
  LYR4 w0.133: v2(28.09,42.66) 29.29,41.47 33.72,41.47 35.18,42.93 35.18,44.32 38.61,47.75 44.07,47.75 45.09,48.77 P8.21
  BOTTOM w0.121: R110.2 P8.21
MMC1_CMD: length 43.6
  TOP w0.121: P8.20 43.81,51.44 43.81,49.53 45.59,47.75 45.59,39.62 46.42,38.79 46.42,36.75 46.12,36.44 U5.V9
  TOP w0.203: U13.M5 v2(28.09,43.16)
  LYR4 w0.133: v1(42.55,48.26) 38.61,48.26 34.8,44.45 34.8,43.05 33.57,41.83 29.42,41.83 v2(28.09,43.16)
  BOTTOM w0.121: R109.2 v1(42.55,48.26) 41.4,49.4 41.4,51.56 P8.20
MMC1_DAT0: length 34.2
  TOP w0.121: v1(48.9,48.26) 48.39,47.75 48.39,38.67 48.26,38.54 48.26,36.58 48.12,36.44 48.12,35.61 U5.U7 ; v1(38.1,44.96) 37.3,44.16 U13.A3
  LYR4 w0.133: v1(38.1,44.96) 39.5,44.96 41.27,46.74 47.37,46.74 v1(48.9,48.26)
  BOTTOM w0.121: R101.2 v1(48.9,48.26) 48.9,48.9 P8.25
MMC1_DAT1: length 39
  TOP w0.121: P8.24 48.77,51.56 48.77,49.4 48.13,48.77 48.13,38.97 48.01,38.84 48.01,36.7 47.72,36.42 U5.V7 ; v1(38.73,45.72) 38.73,44.83 37.56,43.66 U13.A4
  LYR4 w0.133: v1(46.35,48.26) 45.34,47.24 40.26,47.24 v1(38.73,45.72)
  BOTTOM w0.121: R102.2 v1(46.35,48.26) 46.35,51.44 P8.24
MMC1_DAT2: length 34.9
  TOP w0.121: v1(47.32,34.01) U5.R8
  TOP w0.203: v2(33.66,43.16) U13.A5
  LYR3 w0.121: 46.92,35.05 46.92,34.41 v1(47.32,34.01)
  LYR3 w0.133: v2(33.66,43.16) 34.18,43.69 41.15,43.69 46.23,38.61 46.23,35.81 46.92,35.12 46.92,35.05
  LYR4 w0.133: v1(26.04,48.26) 26.04,47.88 27.69,46.23 29.08,46.23 32.26,43.05 32.26,42.8 32.51,42.55 33.04,42.55 v2(33.66,43.16)
  BOTTOM w0.121: P8.5 26.04,48.9 v1(26.04,48.26) R103.2
MMC1_DAT3: length 34.6
  TOP w0.121: v1(47.32,34.81) U5.T8 ; U13.B2 v2(32.84,44.91)
  LYR3 w0.133: v1(47.32,34.81) 47.32,35.23 46.49,36.06 46.49,38.86 41.27,44.07 33.69,44.07 v2(32.84,44.91)
  LYR4 w0.133: v1(27.3,48.26) 28.19,47.37 30.38,47.37 v2(32.84,44.91)
  BOTTOM w0.121: P8.6 26.04,51.44 26.04,49.53 v1(27.3,48.26) R104.2
MMC1_DAT4: length 37.5
  TOP w0.121: U13.B3 v2(32.84,44.41) ; P8.23 47.12,49.66 47.12,39.62 47.75,38.99 47.75,36.83 47.32,36.4 47.32,35.61 U5.U8
  LYR4 w0.133: v2(32.84,44.41) 33.74,44.41 38.73,49.4 38.73,50.67 39.24,51.18 46.61,51.18 P8.23
  BOTTOM w0.121: R105.2 P8.23
MMC1_DAT5: length 36.7
  TOP w0.121: P8.22 46.35,51.44 46.35,49.78 46.86,49.28 46.86,39.37 46.92,39.31 U5.V8 ; U13.B4 v2(32.84,43.91)
  LYR4 w0.133: v1(43.81,48.26) 43.31,48.77 38.61,48.77 33.75,43.91 v2(32.84,43.91)
  BOTTOM w0.121: R106.2 v1(43.81,48.26) 43.81,51.44 P8.22
MMC1_DAT6: length 36.9
  TOP w0.121: v1(46.52,34.01) U5.R9 ; U13.B5 v2(32.84,43.41)
  LYR3 w0.133: v1(46.52,34.01) 43.81,36.72 43.81,38.86 43.18,39.5 43.18,40.64 41.53,42.29 32.89,42.29 32.51,42.67 32.51,43.08 v2(32.84,43.41)
  LYR4 w0.133: v1(23.5,48.26) 24.26,49.02 26.54,49.02 26.9,48.67 26.9,48.03 27.94,46.99 29.08,46.99 32.66,43.41 v2(32.84,43.41)
  BOTTOM w0.121: R107.2 v1(23.5,48.26) 23.5,48.9 P8.3
MMC1_DAT7: length 36.9
  TOP w0.121: U13.B6 v2(32.84,42.91) ; v1(46.52,34.81) U5.T9
  LYR3 w0.133: v2(32.84,42.91) 33.27,42.91 33.51,42.67 41.66,42.67 43.56,40.77 43.56,39.62 44.2,38.99 44.2,37.13 v1(46.52,34.81)
  LYR4 w0.133: v2(32.84,42.91) 32.78,42.91 29.08,46.61 27.81,46.61 26.54,47.88 26.54,48.39 26.26,48.67 25.17,48.67 v1(24.77,48.26)
  BOTTOM w0.121: R108.2 v1(24.77,48.26) 23.5,49.53 23.5,51.44 P8.4
MODE2: length 3.9
  TOP w0.121: v1(28.45,32.7) 28.11,32.37 U14.15
  BOTTOM w0.121: R138.2 R113.1 29.4,33.66 v1(28.45,32.7)
OSC0_IN: length 6.8
  TOP w0.121: U5.V10 45.32,37.7 v1(45.72,38.1)
  BOTTOM w0.121: v1(45.72,38.1) R17.1 C25.1 46.86,41.15 Y2.2
OSC0_OUT: length 7.7
  TOP w0.121: U5.U11 44.92,35.61 v1(44.92,38.1)
  BOTTOM w0.121: Y2.1 43.56,41.15 C26.1 R17.2 44.7,38.32 v1(44.92,38.1)
OSC1_IN: length 8.1
  TOP w0.121: Y1.1 49.93,16.72 50.16,16.95 v1(50.16,17.78) 50.16,18.67 49.66,19.18 49.66,21.27 U5.A6
  BOTTOM w0.121: C21.2 50.48,17.46 v1(50.16,17.78)
OSC1_OUT: length 8.2
  TOP w0.121: Y1.4 52.31,16.72 52.07,16.95 v1(52.07,17.78) 50.36,19.49 50.36,21.65 50.12,21.89 U5.A4
  BOTTOM w0.121: v1(52.07,17.78) 51.75,17.46 C22.2
P_BYPASS: length 2.8
  TOP w0.121: U2.47 21.06,18.88 20.83,19.11 v1(20,19.11)
  BOTTOM w0.121: C4.2 v1(20,19.11)
P_INT_LDO: length 4.4
  TOP w0.121: C3.2 v1(18.8,19.37) 19.85,18.31 U2.48
P_L1: length 4.6
  TOP w0.203: U2.20 23.46,11.18
  BOTTOM w0.381: v1(22.99,9.91) v1(22.35,9.91) 22.35,8.89 L1.1 22.99,8.89 v1(22.99,9.91)
P_L2: length 4.5
  TOP w0.203: 24.66,11.53 U2.23
  BOTTOM w0.381: v1(24.64,9.91) 24.51,9.91 24.38,9.78 24.38,8.7 L2.1 25.15,9.21 25.15,9.78 v1(25.27,9.91) v1(24.64,9.91)
P_L3: length 2.9
  BOTTOM w0.381: 28.57,16.7 L3.1 29.21,16.7 v1(29.21,17.4) v1(28.57,17.4) 28.57,16.7
PHY_VDDCR: length 4.1
  TOP w0.254: v1(26.23,27.69) 26.21,27.69 25.83,28.06 U14.6
  BOTTOM w0.381: C136.1 C134.1 27.18,27.93 26.93,27.69 v1(26.23,27.69)
PHY_XTAL1: length 4.7
  TOP w0.121: v1(28.26,25.4) 27.3,25.4 Y3.1
  BOTTOM w0.121: R141.2 R142.1 C143.1 27.18,25.4 v1(28.26,25.4)
PHY_XTAL2: length 3.4
  TOP w0.121: v1(25.08,26.99) 24.9,27.17 24.9,27.87 24.83,27.94 U14.4
  BOTTOM w0.121: R143.1 R141.1 v1(25.08,26.99)
PHYX: length 3.7
  TOP w0.121: Y3.2 22.87,25.4 v1(21.91,25.4)
  BOTTOM w0.121: R143.2 C142.1 22.99,25.4 v1(21.91,25.4)
PMIC_INT: length 25.3
  TOP w0.121: U2.45 21.86,19.35 v1(21.59,19.62) ; U5.B18 37.59,21.88 37.59,20.7 36.96,20.07 v1(36.96,19.68)
  LYR3 w0.133: v1(21.59,19.62) 22.03,20.07 29.72,20.07 30.48,20.83 33.15,20.83 34.8,19.18 36.45,19.18 v1(36.96,19.68)
  BOTTOM w0.121: R1.2 22.67,21.4 21.59,20.32 v1(21.59,19.62)
PMIC_PGOOD: length 26.8
  TOP w0.121: v1(40.92,22.81) U5.B15 ; v1(26.92,12.76) 26.56,13.13 26.56,13.23 26.35,13.44 U2.26
  LYR3 w0.121: v1(40.92,22.81) 40.52,23.21 39.95,23.21
  LYR3 w0.133: 39.95,23.21 35.92,23.21 35.91,23.22 32.66,23.22 32,23.88 29.72,23.88 v1(29.21,24.38)
  LYR4 w0.133: v1(29.21,24.38) 28.07,23.24 28.07,13.91 v1(26.92,12.76)
PMIC_POWR_EN: length 66
  TOP w0.121: v1(18.29,14.24) U2.9 ; v1(48.92,23.61) U5.C6
  LYR3 w0.133: v1(18.29,14.24) 18.34,14.24 19.56,13.02 19.56,9.65 20.19,9.02 29.59,9.02 30.86,7.75 38.23,7.75 39.37,6.6 55.88,6.6 57.02,7.75 v1(57.02,10.92)
  LYR4 w0.133: v1(48.92,23.61) 48.92,22.45 51.56,19.81 51.56,19.05 54.48,16.13 54.48,12.83 56.39,10.92 v1(57.02,10.92)
PROC_A15: length 15.2
  TOP w0.121: v1(39.88,11.94) 38.86,12.95 38.86,15.88 38.34,16.4 38.34,20.18 39.62,21.46 40.37,21.46 v1(40.92,22.01) U5.A15
  BOTTOM w0.121: v1(39.88,11.94) 40.39,12.45 41.4,12.45 R18.1
PWR_BUT: length 60.6
  TOP w0.121: U2.25 25.93,12.55 26.42,12.06 v1(26.92,12.06) ; S3.4 S3.2 10.83,41.11 11.56,40.39 v1(14.1,40.39)
  LYR4 w0.133: P9.9 28.57,3.17 28.57,5.21 29.46,6.1 29.46,9.53 v1(26.92,12.06) 25.65,13.34 25.65,18.8 21.97,22.48 15.11,22.48 13.34,24.26 13.34,35.43 13.84,35.94 13.84,40.13 v1(14.1,40.39)
PWR_LEDR: length 2.3
  TOP w0.121: v1(3.05,17.27) 2.98,17.21 D1.1
  BOTTOM w0.121: R12.2 3.3,17.02 v1(3.05,17.27)
